## kernelsu/ksu_preinit_demo/lkm_src/Kconfig
```kconfig
menu "LKM HELLO"

config LKM_HELLO
	tristate "LKM HELLO"
	default m
	help
	  simple LKM demo

endmenu
```
